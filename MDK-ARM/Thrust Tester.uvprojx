# Keil uVision project Thrust Tester.uvprojx, settings and files
target Thrust Tester (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Thrust Tester
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;                   ../Drivers/STM32F1xx_HAL_Driver/Inc;                   ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                   ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                   ../Drivers/CMSIS/Include;                   ..\Inc\libfixmath;                   ..\Inc\motion_driver_5.1.3;                   ..\Inc\pt-1.5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: debug.c ppm.c pwm.c retarget_io.c rpm.c mpu6050.c hx711.c protocol.c stm_flash.c terminal.c main.c gpio.c adc.c dma.c i2c.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Libaries/libfixmath
    ../Src/libfixmath/: fix16.c fix16_sqrt.c
  group Libraries/pt
    ../Inc/pt-1.5/: graham-pt.h lc.h lc-addrlabels.h lc-switch.h pt.h pt-sem.h
  group Libraries/MPU6050
    ../Src/motion_driver_5.1.3/: inv_mpu.c inv_mpu_dmp_motion_driver.c
